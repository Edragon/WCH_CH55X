# Keil uVision project ch554_txm.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: R2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src
  group Source Group 1
    ../src/: Debug.C GPIO.C Main.C UART1.C
