# Keil uVision project CH554.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH554 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: CH554DEMO2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src
  group Source Group 1
    ../src/: Debug.C GPIO.C Main.C TouchKey.C
