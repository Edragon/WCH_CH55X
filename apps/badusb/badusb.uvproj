# Keil uVision project badusb.uvproj, settings and files
target 目标 1 (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: badusb +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./Public/: DEBUG.C
    ./USB/: Key.C
    ./: main..c
